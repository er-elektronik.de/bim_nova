Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: NOH-UM - Wand.IFC
Time: 2021-09-03T08:09:05
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Akkus BIM_Akkustab
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: Elektronik BIM
In: Default Storey
Material: Steel
SolidWorks Custom Properties - Version 1: AX3 - AT DS&BS,LFP 3,2V 3h 1,2W; Version 2: AX8 - AT DS&BS,LFP 3,2V 8h 1,2W; Version 3: C - für zentrale Versorgung AC/DC; Version 4: Q - zent.Vers. AC/DC Kinoschaltung

# IfcBuildingElementProxy: Montagefläche_300x200
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: NO Haube BIM_NO Haube
In: Default Storey
Material: PC
SolidWorks Custom Properties - Material: PC; Gewicht: 166.74

# IfcBuildingElementProxy: NO LED- Streifen BIM_NOVA LED Stripe
In: Default Storey
Material: Steel
SolidWorks Custom Properties - Version 1: SN-LED 4000K neutralweiß BLF100%; Version 2: SL-LED 5500K neutralweiß BLF100%

# IfcBuildingElementProxy: NO Piktoset BIM_Nova Klebefolie rechts-links
In: Default Storey
Material: Steel
SolidWorks Custom Properties - Erkennungsweite: 25m; Version 1: 00 - Ohne Piktogramm; Version 2: 20 - Piktoset LMU/R/L DIN7010; Version 3: 24 - Piktoset LM-OR/OL (7010); Version 4: 29 - Auslegerpiktos LMU/U/R/L(7010)

# IfcBuildingElementProxy: NO Profil_Profil 24m
In: Default Storey
Material: AL Mg Si 0,5
SolidWorks Custom Properties - Material: AL Mg Si 0,5; Gewicht: 182.57; Bezeichnung: Aluprofil

# IfcBuildingElementProxy: Nova Endkappe_Endkappe (2)
In: Default Storey
Material: PA 66
SolidWorks Custom Properties - Material: PA 66; Gewicht: 7.50; Bezeichnung: Nova Endkappe

# IfcElementAssembly: NOH-UM - Wand
In: Default Storey
SolidWorks Custom Properties - Wartungsintervall: Brenndauertest jährlich
PSet_Mass_Property - Mass Measure: 0.446245; Area Measure: 0.47563 m2; Volume Measure: 0.000302827 m3
