Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: NO8-UM - Wand.IFC
Time: 2021-09-03T08:07:14
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Acrylscheibe 10mm_EKW 34m
In: Default Storey
Material: Acrylglas
SolidWorks Custom Properties - Material: Acrylglas; Gewicht: 403.33; Version 1: EKW 17m; Version 2: EKW 25m; Version 3: EKW 34m

# IfcBuildingElementProxy: Akkus BIM_Akkustab
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: Elektronik BIM
In: Default Storey
Material: Steel
SolidWorks Custom Properties - Version 1: AX3 - AT DS&BS,LFP 3,2V 3h 1,2W; Version 2: AX8 - AT DS&BS,LFP 3,2V 8h 1,2W; Version 3: C - für zentrale Versorgung AC/DC; Version 4: Q - zent.Vers. AC/DC Kinoschaltung

# IfcBuildingElementProxy: Montagefläche_400x300
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: NO LED- Streifen BIM_NOVA LED Stripe
In: Default Storey
Material: Steel
SolidWorks Custom Properties - Version 1: SN-LED 4000K neutralweiß BLF100%; Version 2: SL-LED 5500K neutralweiß BLF100%

# IfcBuildingElementProxy: NO Profil_Profil 32m
In: Default Storey
Material: AL Mg Si 0,5
SolidWorks Custom Properties - Material: AL Mg Si 0,5; Gewicht: 182.57; Bezeichnung: Aluprofil

# IfcBuildingElementProxy: Nova Endkappe_Endkappe (2)
In: Default Storey
Material: PA 66
SolidWorks Custom Properties - Material: PA 66; Gewicht: 7.50; Bezeichnung: Nova Endkappe

# IfcBuildingElementProxy: Safelight Folien BIM_Piktofolie EKW 34m (2)
In: Default Storey
Material: PET
SolidWorks Custom Properties - Version 1: 00 - Piktogrammfolien f. Sonderpikto; Version 2: 20 - Piktoset LMU/R/L/Blind DIN7010; Version 3: 24 - Piktoset LM-OR/UL-UR/UL (7010); Version 4: 29 - Auslegerpiktos LMU/U/R/L(7010)

# IfcElementAssembly: NO8-UM - Wand
In: Default Storey
SolidWorks Custom Properties - Wartungsintervall: Brenndauertest jährlich
PSet_Mass_Property - Mass Measure: 1.10389; Area Measure: 0.740669 m2; Volume Measure: 0.000817865 m3
